# Keil uVision project multiplication_using_addition.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8051 (all Variants) Generic
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: multiplication_using_addition
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: multiplication_using_addition.asm

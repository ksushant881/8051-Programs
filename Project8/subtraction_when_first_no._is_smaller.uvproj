# Keil uVision project subtraction_when_first_no._is_smaller.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8051 (all Variants) Generic
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: subtraction_when_first_no._is_smaller
  c flags: Optimize=8 SizeSpeed=1
